FILESEXTRAPATHS:prepend:system-controller := "${THISDIR}/${PN}:"

